# Keil uVision project zhangchenhao.uvprojx, settings and files
target LED (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c include: ..\CORE;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\SYSTEM\datatype;..\SYSTEM\systick;..\HARDWARE\Timer;..\HARDWARE\RCC;..\TM;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE\PWM;..\USER;..\;..\HARDWARE?\stm;..\FWLIB\src;..\TM\tm_stm32f4_spi_dma.h;..\TM\tm_stm32f4_spi_dma.h;..\TM\tm_stm32f4_ili9341.h;..\TM\tm_stm32f4_font.h;..\HARDWARE\ADC3\adc3.h;..\HARDWARE\LSENS\lsens.h;..\HARDWARE\ADC3;..\HARDWARE\LSENS;..\HARDWARE\ADC3;..\FWLIB\src;..\FWLIB\inc\stm32f4xx_fsmc.h;..\FWLIB\inc;..\HARDWARE\LSENS;..\SYSTEM\usart;..\SYSTEM\usart\usart.h
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x800000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c main.h
    ../source/: stm32f4xx_dma.c stm32f4xx_spi.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Timer/: Timer.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/RCC/: RCC.c
    ./: key.c key.h lcd.h lcd.c font.h font.c
    ../HARDWARE/stm/: stm32f4xx_hal_conf.h stm32f4xx_hal.h
    ../HARDWARE/LSENS/: lsens.c lsens.h
    ../HARDWARE/ADC3/: adc3.c adc3.h
  group TM
    ./: attributes.h
    ../TM/: tm_stm32f4_dma.c tm_stm32f4_fonts.c tm_stm32f4_gpio.c tm_stm32f4_ili9341.c tm_stm32f4_spi.c tm_stm32f4_spi.h tm_stm32f4_spi_dma.c tm_stm32f4_spi_dma.h defines.h tm_stm32f4_dma.h tm_stm32f4_fonts.h tm_stm32f4_gpio.h tm_stm32f4_ili9341.h
  group SYSTEM
    ../SYSTEM/systick/: SysTick.c
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f429_439xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_pwr.c stm32f4xx_adc.c
    ../FWLIB/inc/: stm32f4xx_fsmc.h misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
